File: bmd.sch (KiCad schematic (older format))
At the start: 25 parts

Commit message: 20191113未完工
Parts:
- gave numbers to parts that had none: 24
